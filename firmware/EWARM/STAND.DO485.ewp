# IAR project STAND.DO485.ewp, settings and files
configuration TTOOL2 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STAND.DO485.hex
  ILINK.IlinkOutputFile: CHG.CTRL.CPU.out
configuration UPSCPU (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkOutputFile: STAND.DO485.out
configuration CHG.CTRL.CPU (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\STM32F10x_StdPeriph_Driver\inc; ..\
configuration STAND.DO485 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F100x4 ST STM32F100x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD_VL
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group EWARMv5
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_md_vl.s
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../: crc16.c defines.h digits_display.c flashdata.c id.c init.c main.c memutil.c modbus.c ramdata.c stm32f10x_it.c uart1rs485.c
